# Keil uVision project FIBONACCI.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FIBONACCI
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: fibonacci.s nacci.s
software components: CMSIS Driver:CAN:Custom 1.0.0, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, CMSIS:NN Lib 7.0.0, CMSIS Driver:CAN 1.10, Device:GPIO 1.3
